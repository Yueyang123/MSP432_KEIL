# Keil uVision project MSP432_CAR.uvprojx, settings and files
target MSP432_CAR (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432_CAR
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\LIB\inc;..\LIB\inc\CMSIS;..\SYSTEM;..\LIB\driverlib\MSP432P4xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group USER
    ./: startup_msp432p401r_uvision.s system_msp432p401r.c main.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group LIB
    F:/电设/源码整理/MSP432_CAR/LIB/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
